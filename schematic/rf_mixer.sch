v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {according to some, mixer should actually do something} -180 -260 0 0 0.4 0.4 {}
T {last update: 2025-01-05 HW} 260 150 0 0 0.4 0.4 {}
T {RF mixer} -100 -510 0 0 1 1 {}
C {ipin.sym} -180 -40 0 0 {name=p1 lab=rf_in}
C {opin.sym} 320 0 0 0 {name=p2 lab=out}
C {ipin.sym} -180 90 0 0 {name=p5 lab=GND}
C {ipin.sym} -180 -100 0 0 {name=p4 lab=1V8}
C {noconn.sym} -180 -100 0 1 {name=l1}
C {ipin.sym} -180 30 0 0 {name=p3 lab=lo_in}
C {noconn.sym} -180 90 0 1 {name=l4}
C {noconn.sym} 320 0 0 0 {name=l5}
C {noconn.sym} -180 30 0 1 {name=l2}
C {noconn.sym} -180 -40 0 1 {name=l3}
